Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[Pasport TZ]
File name: /dev/null
Time: 2026-08-05T13:13:04+02:00
Written by: IfcOpenShell 0.8.5
Made in: IfcOpenShell 0.8.5
Authorization: Nobody

# IfcProject, 1658
Description: CSAS Praha 10 Nové náměstí 1257/8; Phase: Provozní; Classification: CS-BIM
CSBIM_SourcePset - SourceCreatedOn: 2026-08-03T20:07:56+02:00; SourceExporter: CSPAS; SourceExporterVersion: 3.1; SourceDomain: csdev.fmleven.cz; FacilityId: 1; SourceLengthUnit: M; SourceAngleUnit: DEGREE; SourceGeometryMode: swept_solid; SourceSpaceGeometrySource: GeometryData; SourceElementGeometrySource: Coordinates; SourceTypeGeometrySource: Coordinates

# IfcSite, Default_Site
Description: Lokální projektový souřadnicový systém bez ověřené geodetické reference. Model je určen pro technickou správu budovy a interní prostorovou koordinaci; není určen pro geodetické, katastrální, GIS ani právní účely.

# IfcBuilding, 1658
Description: CSAS Praha 10 Nové náměstí 1257/8
CSBIM_SourcePset - SourceTable: cobie_Facility; SourceId: 1; SourceKey: 1658

# IfcBuildingStorey, 1658_gf
In: 1658
Description: 1.NP; Elevation: 0 m
CSBIM_SourcePset - SourceTable: cobie_Floor; SourceId: 1; SourceKey: 1658_gf

# IfcSpace: IT místnost, 1658/gf/106:1658
In: 1658_gf
Description: IT; LongName: IT; PredefinedType: SPACE; Classification: ITRoom IT místnost (CS-BIM)
CSBIM_Pset - Area: 5.31; CeilingFinish: jiný materiál a kombinace; Description: IT; Floor: 1658_gf; FloorFinish: PVC; Height: 2700; RoomNumber: 106; Usage: IT místnost; WallFinish: omítka
CSBIM_Generator_Pset - RoomNumber: 106
CSBIM_SourcePset - SourceTable: cobie_Space; SourceId: 5; SourceKey: 1658/gf/106:1658

# IfcSpace: WC (2)
In: 1658_gf
Description: WC; LongName: WC; PredefinedType: SPACE; Classification: Toilet WC (CS-BIM)
CSBIM_Pset - CeilingFinish: jiný materiál a kombinace; Description: WC; Floor: 1658_gf; FloorFinish: Ceramic tile; Height: 2700; Usage: WC
CSBIM_SourcePset - SourceTable: cobie_Space
Name | Area | CSBIM_Pset, RoomNumber = CSBIM_Generator_Pset, RoomNumber | WallFinish | SourceId | SourceKey
1658/gf/108:1658 | 1.53 | 108 | omítka | 6 | 1658/gf/108:1658
1658/gf/110:1658 | 1.85 | 110 | dlažba | 2 | 1658/gf/110:1658

# IfcSpace: bankomat ATM (2)
In: 1658_gf
Description: Bankomat; LongName: Bankomat; PredefinedType: SPACE; Classification: ATM bankomat ATM (CS-BIM)
CSBIM_Pset - Description: Bankomat; Floor: 1658_gf; FloorFinish: Ceramic tile; Height: 2700; Usage: bankomat ATM; WallFinish: omítka
CSBIM_SourcePset - SourceTable: cobie_Space
Name | Area | CeilingFinish | CSBIM_Pset, RoomNumber = CSBIM_Generator_Pset, RoomNumber | SourceId | SourceKey
1658/gf/111:1658 | 6.36 | jiný materiál a kombinace | 111 | 10 | 1658/gf/111:1658
1658/gf/112:1658 | 5.13 | štuk | 112 | 11 | 1658/gf/112:1658

# IfcSpace: bankovní hala, 1658/gf/102:1658
In: 1658_gf
Description: Bankovní hala; LongName: Bankovní hala; PredefinedType: SPACE; Classification: BankingHall bankovní hala (CS-BIM)
CSBIM_Pset - Area: 70.99; CeilingFinish: jiný materiál a kombinace; Description: Bankovní hala; Floor: 1658_gf; FloorFinish: Carpet/Ceramic tile; Height: 2700; RoomNumber: 102; Usage: bankovní hala; WallFinish: omítka
CSBIM_Generator_Pset - RoomNumber: 102
CSBIM_SourcePset - SourceTable: cobie_Space; SourceId: 8; SourceKey: 1658/gf/102:1658

# IfcSpace: chodba, 1658/gf/103:1658
In: 1658_gf
Description: Chodba; LongName: Chodba; PredefinedType: SPACE; Classification: Corridor chodba (CS-BIM)
CSBIM_Pset - Area: 6.1; CeilingFinish: jiný materiál a kombinace; Description: Chodba; Floor: 1658_gf; FloorFinish: Carpet; Height: 2700; RoomNumber: 103; Usage: chodba; WallFinish: omítka
CSBIM_Generator_Pset - RoomNumber: 103
CSBIM_SourcePset - SourceTable: cobie_Space; SourceId: 3; SourceKey: 1658/gf/103:1658

# IfcSpace: jednací prostory (2)
In: 1658_gf
Description: Jednací místnost; LongName: Jednací místnost; PredefinedType: SPACE; Classification: MeetingSpaces jednací prostory (CS-BIM)
CSBIM_Pset - CeilingFinish: jiný materiál a kombinace; Description: Jednací místnost; Floor: 1658_gf; FloorFinish: Carpet; Height: 2700; Usage: jednací prostory; WallFinish: omítka
CSBIM_SourcePset - SourceTable: cobie_Space
Name | Area | CSBIM_Pset, RoomNumber = CSBIM_Generator_Pset, RoomNumber | SourceId | SourceKey
1658/gf/104:1658 | 13.54 | 104 | 4 | 1658/gf/104:1658
1658/gf/113:1658 | 9.46 | 113 | 9 | 1658/gf/113:1658

# IfcSpace: kuchyňka, 1658/gf/105:1658
In: 1658_gf
Description: Kuchyňka; LongName: Kuchyňka; PredefinedType: SPACE; Classification: Kitchenette kuchyňka (CS-BIM)
CSBIM_Pset - Area: 14.7; CeilingFinish: jiný materiál a kombinace; Description: Kuchyňka; Floor: 1658_gf; FloorFinish: PVC; Height: 2700; RoomNumber: 105; Usage: kuchyňka; WallFinish: omítka
CSBIM_Generator_Pset - RoomNumber: 105
CSBIM_SourcePset - SourceTable: cobie_Space; SourceId: 14; SourceKey: 1658/gf/105:1658

# IfcSpace: umývárna, 1658/gf/109:1658
In: 1658_gf
Description: Umývárna; LongName: Umývárna; PredefinedType: SPACE; Classification: Washroom umývárna (CS-BIM)
CSBIM_Pset - Area: 1.85; CeilingFinish: jiný materiál a kombinace; Description: Umývárna; Floor: 1658_gf; FloorFinish: Ceramic tile; Height: 2700; RoomNumber: 109; Usage: umývárna; WallFinish: dlažba
CSBIM_Generator_Pset - RoomNumber: 109
CSBIM_SourcePset - SourceTable: cobie_Space; SourceId: 7; SourceKey: 1658/gf/109:1658

# IfcSpace: venkovní prostor, 1658/gf/100:1658
In: 1658_gf
Description: Chodník; LongName: Chodník; PredefinedType: SPACE; Classification: OutdoorSpace venkovní prostor (CS-BIM)
CSBIM_Pset - Area: 23.34; CeilingFinish: omítka; Description: Chodník; Floor: 1658_gf; FloorFinish: Cement tile; Height: 3500; RoomNumber: 100; Usage: venkovní prostor; WallFinish: omítka
CSBIM_Generator_Pset - RoomNumber: 100
CSBIM_SourcePset - SourceTable: cobie_Space; SourceId: 12; SourceKey: 1658/gf/100:1658

# IfcSpace: vstupní lobby, 1658/gf/101:1658
In: 1658_gf
Description: Zádveří; LongName: Zádveří; PredefinedType: SPACE; Classification: EntranceLobby vstupní lobby (CS-BIM)
CSBIM_Pset - Area: 7.26; CeilingFinish: jiný materiál a kombinace; Description: Zádveří; Floor: 1658_gf; FloorFinish: Ceramic tile/Doormat; Height: 2700; RoomNumber: 101; Usage: vstupní lobby; WallFinish: omítka
CSBIM_Generator_Pset - RoomNumber: 101
CSBIM_SourcePset - SourceTable: cobie_Space; SourceId: 13; SourceKey: 1658/gf/101:1658

# IfcSpace: úklidová místnost, 1658/gf/114:1658
In: 1658_gf
Description: Úklid; LongName: Úklid; PredefinedType: SPACE; Classification: CustodialRoom úklidová místnost (CS-BIM)
CSBIM_Pset - Area: 1.1; CeilingFinish: jiný materiál a kombinace; Description: Úklid; Floor: 1658_gf; FloorFinish: Ceramic tile; Height: 2700; RoomNumber: 114; Usage: úklidová místnost; WallFinish: omítka
CSBIM_Generator_Pset - RoomNumber: 114
CSBIM_SourcePset - SourceTable: cobie_Space; SourceId: 1; SourceKey: 1658/gf/114:1658

# IfcBuildingElementProxy: PBZ_SPPO_ZUC (2)
Description: PBZ · Systém pasivní požární ochrany · Značení únikových cest; Classification: PBZ_SPPO_ZUC Značení únikových cest (CS-BIM)
CSBIM_Pset - BatterySource: ano; CircuitBreaker: neodpovídá typu; CircuitNumber: neodpovídá typu; Description: PBZ · Systém pasivní požární ochrany · Značení únikových cest; FamilyName: Nouzové osvětlení; Floor: gf; HeightAboveFloor: 2310; InitialInspection: nezjištěno; LightingCircuit: neodpovídá typu; Power: neodpovídá typu; RequiresCheck: ano; RequiresInspection: ano; Switchboard: neodpovídá typu; TechnicalDocumentation: nezjištěno; Type1: PBZ; Type2: Systém pasivní požární ochrany; Type3: Značení únikových cest; TypeName: PBZ_SPPO_ZUC
CSBIM_SourcePset - SourceTable: cobie_Component; GeometryMode: bounding_box; GeometrySourceTable: cobie_Component; GeometryRule: component_box; GeometryReason: CadType!=Object|missing_type_geometry
Name | In | BatteryCount | BatteryType | Code = SourceKey = GeometrySourceKey | InputPower | Location | Manufacturer | RoomNumber | TypeDesignation | Voltage | SourceId
PBZ_SPPO_ZUC_1658_002 | 1658/gf/102:1658 | 1 | LiFePO4/C 3.2V 3.0Ah | PBZ_SPPO_ZUC_1658_002 | 5.0 W | interiér – strop nad dveřmi | TM Technologie | 1658/gf/102:1658 | TM PNTEC.9 | 210–250 V AC 50–60 Hz | 26
PBZ_SPPO_ZUC_1658_001 | 1658/gf/103:1658 | nezjištěno | nezjištěno | PBZ_SPPO_ZUC_1658_001 | nezjištěno | interiér – nad dveřmi | nezjištěno | 1658/gf/103:1658 | nezjištěno | 230 V | 44

# IfcDoor: OB_INT_DV (14)
Description: Objekt · Interiéry · Dveře; Classification: OB_INT_DV Dveře (CS-BIM)
CSBIM_Pset - CircuitNumber: neodpovídá typu; Description: Objekt · Interiéry · Dveře; Designation: nezjištěno; FireResistance: nezjištěno; Floor: gf; HeightAboveFloor: 0; Manufacturer: nezjištěno; OpeningType: otočné; Switchboard: neodpovídá typu; TechnicalDocumentation: nezjištěno; Type1: Objekt; Type2: Interiéry; Type3: Dveře; TypeDesignation: nezjištěno; TypeName: OB_INT_DV
CSBIM_SourcePset - SourceTable: cobie_Component; GeometryMode: bounding_box; GeometrySourceTable: cobie_Component; GeometryRule: component_box; GeometryReason: CadType!=Object|missing_type_geometry
Name | In | Code = SourceKey = GeometrySourceKey | Color | FamilyName | FillMaterial | HardwareType | InitialInspection | LeafType | Location | RoomNumber | SourceId | FrameMaterial | Material
OB_INT_DV_1658_012 | 1658/gf/101:1658 | OB_INT_DV_1658_012 | kovový rám – tmavý; sklo čiré | Dveře | sklo | madlo/klika; horní zavírací mechanismus | neodpovídá typu | prosklené | zádveří / vstupní prostor budovy | 1658/gf/101:1658 | 9
OB_INT_DV_1658_013 | 1658/gf/101:1658 | OB_INT_DV_1658_013 | kovový rám – tmavý; sklo čiré | Dveře | sklo | madlo/klika; horní zavírací mechanismus | neodpovídá typu | prosklené | zádveří / vstupní prostor budovy | 1658/gf/101:1658 | 8
OB_INT_DV_1658_014 | 1658/gf/101:1658 | OB_INT_DV_1658_014 | kovový rám – tmavý; sklo matované | Dveře |  | jednoduché madlo; mechanický zámek | neodpovídá typu | prosklené | interiér budovy (administrativní prostor) | 1658/gf/101:1658 | 7
OB_INT_DV_1658_002 | 1658/gf/103:1658 | OB_INT_DV_1658_002 | bílá | nezjištěno | voština | klika + zámek | ne | jednokřídlé | interiér | 1658/gf/103:1658 | 46 | ocel | sololit
OB_INT_DV_1658_001 | 1658/gf/104:1658 | OB_INT_DV_1658_001 | tmavá (černá/antracit) | nezjištěno | sklo | klika + zámek | ne | jednokřídlé | interiér – kancelář | 1658/gf/104:1658 | 52 | hliník | nezjištěno
OB_INT_DV_1658_003 | 1658/gf/105:1658 | OB_INT_DV_1658_003 | bílá | Dveře | nezjištěno | klika na rozetě; zámek s cylindrickou vložkou | neodpovídá typu | plné, hladké | interiér budovy (přesné umístění nezjištěno) | 1658/gf/105:1658 | 68 | nezjištěno | nezjištěno
OB_INT_DV_1658_004 | 1658/gf/106:1658 | OB_INT_DV_1658_004 | bílá | Dveře | nezjištěno | klika na rozetě; zámek s cylindrickou vložkou | neodpovídá typu | plné, hladké | interiér budovy (přesné umístění nezjištěno) | 1658/gf/106:1658 | 82 | nezjištěno | nezjištěno
OB_INT_DV_1658_005 | 1658/gf/106:1658 | OB_INT_DV_1658_005 | bílá / světle šedá | Dveře | nezjištěno | kulaté rozety; zámek s cylindrickou vložkou | neodpovídá typu | plné, hladké | interiér budovy (chodba; přesné umístění nezjištěno) | 1658/gf/106:1658 | 81 | nezjištěno | nezjištěno
OB_INT_DV_1658_007 | 1658/gf/108:1658 | OB_INT_DV_1658_007 | bílá | Dveře | nezjištěno | klika na kulaté rozetě; zámek s cylindrickou vložkou | neodpovídá typu | plné, hladké | interiér budovy (hygienický / technický prostor; přesné umístění nezjištěno) | 1658/gf/108:1658 | 87 | nezjištěno | nezjištěno
OB_INT_DV_1658_006 | 1658/gf/109:1658 | OB_INT_DV_1658_006 | bílá | Dveře | nezjištěno | klika na kulaté rozetě; zámek s cylindrickou vložkou | neodpovídá typu | plné, hladké | interiér budovy (chodba; přesné umístění nezjištěno) | 1658/gf/109:1658 | 91 | nezjištěno | nezjištěno
OB_INT_DV_1658_008 | 1658/gf/110:1658 | OB_INT_DV_1658_008 | bílá | Dveře | nezjištěno | klika na kulaté rozetě; zámek s cylindrickou vložkou | neodpovídá typu | plné, hladké | interiér budovy (hygienický / technický prostor; přesné umístění nezjištěno) | 1658/gf/110:1658 | 95 | nezjištěno | nezjištěno
OB_INT_DV_1658_011 | 1658/gf/111:1658 | OB_INT_DV_1658_011 | bílá | Dveře | nezjištěno | klika/pevná část na rozetě; zámek s cylindrickou vložkou; dveřní zavírač | neodpovídá typu | plné | interiér budovy (provozní/chodba; přesné umístění nezjištěno) | 1658/gf/111:1658 | 99 | nezjištěno | nezjištěno
OB_INT_DV_1658_010 | 1658/gf/113:1658 | OB_INT_DV_1658_010 | černý rám; transparentní sklo s matnou fólií | Dveře | sklo | klika na rozetě; zámek s cylindrickou vložkou | neodpovídá typu | prosklené | interiér budovy (administrativní prostor; přesné umístění nezjištěno) | 1658/gf/113:1658 | 108 | hliník | nezjištěno
OB_INT_DV_1658_009 | 1658/gf/114:1658 | OB_INT_DV_1658_009 | bílá | Dveře | nezjištěno | klika na kulaté rozetě; zámek s cylindrickou vložkou | neodpovídá typu | plné, hladké | interiér budovy (přesné umístění nezjištěno) | 1658/gf/114:1658 | 116 | nezjištěno | nezjištěno

# IfcElectricAppliance: ELSI_NN_HLR, ELSI_NN_HLR_1658_001
In: 1658/gf/102:1658
Description: Silnoproud · Rozvody a zařízení NN · Rozvodna NN-hl. rozvaděče; Classification: ELSI_NN_HLR Rozvodna NN-hl. rozvaděče (CS-BIM)
CSBIM_Pset - BatteryType: neodpovídá typu; CircuitBreaker: 63; CircuitNumber: neodpovídá typu; Code: ELSI_NN_HLR_1658_001; Depth: 240; Description: Silnoproud · Rozvody a zařízení NN · Rozvodna NN-hl. rozvaděče; FamilyName: elektro; Floor: gf; Height: 1605; HeightAboveFloor: 480; InitialInspection: 4.10.2025; Location: vnitřní prostory; Manufacturer: EBA Praha s.r.o.; RoomNumber: 1658/gf/102:1658; Switchboard: neodpovídá typu; TechnicalDocumentation: ESIL/vychozi_revizni_zprava_239_CS_Uhrineves_EBA.pdf; ESIL/kusova_zkouska_rozvadece_RP1.pdf; Type1: Silnoproud; Type2: Rozvody a zařízení NN; Type3: Rozvodna NN-hl. rozvaděče; TypeDesignation: RP1; TypeName: ELSI_NN_HLR; Width: 810
CSBIM_SourcePset - SourceTable: cobie_Component; SourceId: 28; SourceKey: ELSI_NN_HLR_1658_001; GeometryMode: bounding_box; GeometrySourceTable: cobie_Component; GeometrySourceKey: ELSI_NN_HLR_1658_001; GeometryRule: component_box; GeometryReason: CadType!=Object|missing_type_geometry

# IfcElectricAppliance: ELSI_NN_RP, ELSI_NN_RP_1658_001
In: 1658/gf/106:1658
Description: Silnoproud · Rozvody a zařízení NN · Rozvaděče patrové a podružné; Classification: ELSI_NN_RP Rozvaděče patrové a podružné (CS-BIM)
CSBIM_Pset - BatteryType: neodpovídá typu; CircuitNumber: neodpovídá typu; Code: ELSI_NN_RP_1658_001; Description: Silnoproud · Rozvody a zařízení NN · Rozvaděče patrové a podružné; FamilyName: nezjištěno; Floor: gf; HeightAboveFloor: 1320; InitialInspection: nezjištěno; Location: Vnitřní prostor – technická místnost / zázemí; Manufacturer: ELEKTROTREND Pardubice s.r.o.; RoomNumber: 1658/gf/106:1658; Switchboard: neodpovídá typu; TechnicalDocumentation: nezjištěno; Type1: Silnoproud; Type2: Rozvody a zařízení NN; Type3: Rozvaděče patrové a podružné; TypeDesignation: RPR-H; TypeName: ELSI_NN_RP
CSBIM_SourcePset - SourceTable: cobie_Component; SourceId: 79; SourceKey: ELSI_NN_RP_1658_001; GeometryMode: bounding_box; GeometrySourceTable: cobie_Component; GeometrySourceKey: ELSI_NN_RP_1658_001; GeometryRule: component_box; GeometryReason: CadType!=Object|missing_type_geometry

# IfcElectricAppliance: ELSI_OS_EBT (2)
In: 1658/gf/105:1658
Classification: ELSI_OS_EBT Elektro bílá technika (CS-BIM)
CSBIM_Pset - BatteryType: neodpovídá typu; CircuitNumber: neodpovídá typu; FamilyName: nezjištěno; Floor: gf; HeightAboveFloor: 0; InitialInspection: nezjištěno; RoomNumber: 1658/gf/105:1658; Switchboard: neodpovídá typu; TechnicalDocumentation: nezjištěno; Type1: Silnoproud; Type2: Ostatní spotřebiče; Type3: Elektro bílá technika; TypeName: ELSI_OS_EBT
CSBIM_SourcePset - SourceTable: cobie_Component; GeometryMode: bounding_box; GeometrySourceTable: cobie_Component; GeometryRule: component_box; GeometryReason: CadType!=Object|missing_type_geometry
Name | Description = CSBIM_Pset, Description | Code = SourceKey = GeometrySourceKey | Location | Manufacturer | TypeDesignation | SourceId
ELSI_OS_EBT_1658_001 | Myčka | ELSI_OS_EBT_1658_001 | nezjištěno | Electrolux | EES48200L | 71 | CSBIM_Pset - CircuitBreaker: 10
ELSI_OS_EBT_1658_002 | Chladnička | ELSI_OS_EBT_1658_002 | Interiér – kuchyň / zázemí | Philco | nezjištěno | 70

# IfcElectricAppliance: ELSL_OEZ_MR (3)
In: 1658/gf/102:1658
Description: Reproduktor směrové hudby; Classification: ELSL_OEZ_MR Místní rozhlas (CS-BIM)
CSBIM_Pset - BatteryCount: neodpovídá typu; BatterySource: ne; BatteryType: neodpovídá typu; CircuitNumber: neodpovídá typu; Description: Reproduktor směrové hudby; FamilyName: nezjištěno; Floor: gf; HeightAboveFloor: 2670; InitialInspection: neodpovídá typu; InputPower: nezjištěno; Location: strop – podhled; Manufacturer: nezjištěno; Power: nezjištěno; RoomNumber: 1658/gf/102:1658; Switchboard: neodpovídá typu; TechnicalDocumentation: nezjištěno; Type1: Slaboproud; Type2: Ostatní elektronické objektové zařízení; Type3: Místní rozhlas; TypeDesignation: nezjištěno; TypeName: ELSL_OEZ_MR
CSBIM_SourcePset - SourceTable: cobie_Component; GeometryMode: bounding_box; GeometrySourceTable: cobie_Component; GeometryRule: component_box; GeometryReason: CadType!=Object|missing_type_geometry
Name | Code = SourceKey = GeometrySourceKey | SourceId
ELSL_OEZ_MR_1658_001 | ELSL_OEZ_MR_1658_001 | 32
ELSL_OEZ_MR_1658_002 | ELSL_OEZ_MR_1658_002 | 33
ELSL_OEZ_MR_1658_003 | ELSL_OEZ_MR_1658_003 | 34

# IfcElectricAppliance: KN_FO_KT (2)
In: 1658/gf/102:1658
Description: Kancelářská technika: Konica Minolta; Classification: KN_FO_KT Kancelářská technika (CS-BIM)
CSBIM_Pset - BatteryType: neodpovídá typu; CircuitNumber: nezjištěno; Description: Kancelářská technika: Konica Minolta; Floor: gf; HeightAboveFloor: 0; InitialInspection: ne; Location: nezjištěno; Manufacturer: Konica Minolta; RoomNumber: 1658/gf/102:1658; Switchboard: nezjištěno; TechnicalDocumentation: nezjištěno; Type1: Kancelářský nábytek; Type2: Vybavení pro Front Office; Type3: Kancelářská technika; TypeName: KN_FO_KT
CSBIM_SourcePset - SourceTable: cobie_Component; GeometryMode: bounding_box; GeometrySourceTable: cobie_Component; GeometryRule: component_box; GeometryReason: CadType!=Object|missing_type_geometry
Name | Code = SourceKey = GeometrySourceKey | FamilyName | TypeDesignation | SourceId
KN_FO_KT_1658_001 | KN_FO_KT_1658_001 | Multifunkční tiskárny | bizhub 4051i | 31
KN_FO_KT_1658_002 | KN_FO_KT_1658_002 | nezjištěno | bizhub C3351i | 30

# IfcFan: VZT_VEN_ODT (8)
Description: Kruhový ventil; Classification: VZT_VEN_ODT Odtahové (CS-BIM)
CSBIM_Pset - BatteryType: neodpovídá typu; CircuitNumber: neodpovídá typu; Description: Kruhový ventil; FamilyName: nezjištěno; FilterType: neodpovídá typu; Floor: gf; InitialInspection: neodpovídá typu; Location: Interiér – strop (zapuštěné v podhledu); Manufacturer: nezjištěno; Refrigerant: neodpovídá typu; Switchboard: neodpovídá typu; SystemClassification: vzduchotechnika; SystemType: distribuce vzduchu; TechnicalDocumentation: nezjištěno; Type1: VZT; Type2: VZT ventilátory; Type3: Odtahové; TypeDesignation: nezjištěno; TypeName: VZT_VEN_ODT
CSBIM_SourcePset - SourceTable: cobie_Component; GeometryMode: bounding_box; GeometrySourceTable: cobie_Component; GeometryRule: component_box; GeometryReason: CadType!=Object|missing_type_geometry
Name | In | Code = SourceKey = GeometrySourceKey | HeightAboveFloor | RoomNumber | SourceId
VZT_VEN_ODT_1658_001 | 1658/gf/105:1658 | VZT_VEN_ODT_1658_001 | 2200 | 1658/gf/105:1658 | 73 | CSBIM_Pset - BatteryCount: neodpovídá typu; BatterySource: neodpovídá typu; Depth: nezjištěno; Diameter: nezjištěno; Height: nezjištěno; InnerDiameter: neodpovídá typu; InputPower: neodpovídá typu; Length: neodpovídá typu; NominalDiameter: nezjištěno; OuterDiameter: neodpovídá typu; Power: neodpovídá typu; RequiresCheck: nezjištěno; RequiresInspection: neodpovídá typu; ServiceLife: nezjištěno; Size: nezjištěno; Voltage: neodpovídá typu; Volume: neodpovídá typu; WarrantyPeriod: nezjištěno; Weight: nezjištěno; Width: nezjištěno
VZT_VEN_ODT_1658_002 | 1658/gf/105:1658 | VZT_VEN_ODT_1658_002 | 2200 | 1658/gf/105:1658 | 74
VZT_VEN_ODT_1658_004 | 1658/gf/106:1658 | VZT_VEN_ODT_1658_004 | 2420 | 1658/gf/106:1658 | 84
VZT_VEN_ODT_1658_005 | 1658/gf/106:1658 | VZT_VEN_ODT_1658_005 | 2420 | 1658/gf/106:1658 | 83
VZT_VEN_ODT_1658_006 | 1658/gf/108:1658 | VZT_VEN_ODT_1658_006 | 2200 | 1658/gf/108:1658 | 89
VZT_VEN_ODT_1658_007 | 1658/gf/109:1658 | VZT_VEN_ODT_1658_007 | 2200 | 1658/gf/109:1658 | 93
VZT_VEN_ODT_1658_008 | 1658/gf/110:1658 | VZT_VEN_ODT_1658_008 | 2200 | 1658/gf/110:1658 | 97
VZT_VEN_ODT_1658_003 | 1658/gf/114:1658 | VZT_VEN_ODT_1658_003 | 2200 | 1658/gf/114:1658 | 118

# IfcFan: VZT_VEN_PR (8)
Description: anemostat VZT; Classification: VZT_VEN_PR Přívodní (CS-BIM)
CSBIM_Pset - BatteryType: neodpovídá typu; CircuitNumber: neodpovídá typu; Description: anemostat VZT; FamilyName: VVKN; FilterType: neodpovídá typu; Floor: gf; HeightAboveFloor: 2670; InitialInspection: neodpovídá typu; Location: Interiér – strop (akustický podhled); Manufacturer: Systemair; Refrigerant: neodpovídá typu; Switchboard: neodpovídá typu; SystemClassification: vzduchotechnika; SystemType: distribuce vzduchu; TechnicalDocumentation: technický list VVKN – Systemair; Type1: VZT; Type2: VZT ventilátory; Type3: Přívodní; TypeDesignation: VVKN (pravděpodobné dle dokumentace); TypeName: VZT_VEN_PR
CSBIM_SourcePset - SourceTable: cobie_Component; GeometryMode: bounding_box; GeometrySourceTable: cobie_Component; GeometryRule: component_box; GeometryReason: CadType!=Object|missing_type_geometry
Name | In | Code = SourceKey = GeometrySourceKey | RoomNumber | SourceId
VZT_VEN_PR_1658_003 | 1658/gf/102:1658 | VZT_VEN_PR_1658_003 | 1658/gf/102:1658 | 43
VZT_VEN_PR_1658_004 | 1658/gf/102:1658 | VZT_VEN_PR_1658_004 | 1658/gf/102:1658 | 40
VZT_VEN_PR_1658_005 | 1658/gf/102:1658 | VZT_VEN_PR_1658_005 | 1658/gf/102:1658 | 39
VZT_VEN_PR_1658_006 | 1658/gf/102:1658 | VZT_VEN_PR_1658_006 | 1658/gf/102:1658 | 38
VZT_VEN_PR_1658_007 | 1658/gf/104:1658 | VZT_VEN_PR_1658_007 | 1658/gf/104:1658 | 58
VZT_VEN_PR_1658_008 | 1658/gf/104:1658 | VZT_VEN_PR_1658_008 | 1658/gf/104:1658 | 59
VZT_VEN_PR_1658_001 | 1658/gf/113:1658 | VZT_VEN_PR_1658_001 | 1658/gf/113:1658 | 114
VZT_VEN_PR_1658_002 | 1658/gf/113:1658 | VZT_VEN_PR_1658_002 | 1658/gf/113:1658 | 115

# IfcFireSuppressionTerminal: PBZ_PHP_HPP (2)
Description: PBZ · PHP · Hasící přístroj - práškový; Classification: PBZ_PHP_HPP Hasící přístroj - práškový (CS-BIM)
CSBIM_Pset - BatteryCount: neodpovídá typu; BatterySource: ne; BatteryType: neodpovídá typu; Description: PBZ · PHP · Hasící přístroj - práškový; FamilyName: nezjištěno; FireResistance: neodpovídá typu; Floor: gf; InitialInspection: nezjištěno; TechnicalDocumentation: nezjištěno; Type1: PBZ; Type2: PHP; Type3: Hasící přístroj - práškový; TypeName: PBZ_PHP_HPP
CSBIM_SourcePset - SourceTable: cobie_Component; GeometryMode: bounding_box; GeometrySourceTable: cobie_Component; GeometryRule: component_box; GeometryReason: CadType!=Object|missing_type_geometry
Name | In | Code = SourceKey = GeometrySourceKey | HeightAboveFloor | Location | Manufacturer | RoomNumber | TypeDesignation | SourceId
PBZ_PHP_HPP_1658_002 | 1658/gf/102:1658 | PBZ_PHP_HPP_1658_002 | 250 | interiér – chodba | ALBECO spol. s r.o. | 1658/gf/102:1658 | GP6xABC | 27
PBZ_PHP_HPP_1658_001 | 1658/gf/105:1658 | PBZ_PHP_HPP_1658_001 | 330 | interiér | NEURUPPIN | 1658/gf/105:1658 | PGo Euro-P | 65

# IfcFlowMeter: MER_INFO_KAL (5)
Description: Měřidla · Informativní · Kalorimetr; Classification: MER_INFO_KAL Kalorimetr (CS-BIM)
CSBIM_Pset - BatteryType: nezjištěno; Description: Měřidla · Informativní · Kalorimetr; FamilyName: Indikátory spotřeby tepla; FireResistance: neodpovídá typu; Floor: gf; InitialInspection: ne; Location: na otopném tělese; Manufacturer: QUNDIS; TechnicalDocumentation: nezjištěno; Type1: Měřidla; Type2: Informativní; Type3: Kalorimetr; TypeDesignation: Q caloric 5.5 / P3-AMR-WB; TypeName: MER_INFO_KAL
CSBIM_SourcePset - SourceTable: cobie_Component; GeometryMode: bounding_box; GeometrySourceTable: cobie_Component; GeometryRule: component_box; GeometryReason: CadType!=Object|missing_type_geometry
Name | In | Code = SourceKey = GeometrySourceKey | HeightAboveFloor | RoomNumber | SourceId
MER_INFO_KAL_1658_003 | 1658/gf/102:1658 | MER_INFO_KAL_1658_003 | 600 | 1658/gf/102:1658 | 22
MER_INFO_KAL_1658_002 | 1658/gf/104:1658 | MER_INFO_KAL_1658_002 | 600 | 1658/gf/104:1658 | 49 | CSBIM_Pset - BatteryCount: nezjištěno; BatterySource: ano; RequiresCheck: nezjištěno; RequiresInspection: ne; ServiceLife: nezjištěno; WarrantyPeriod: nezjištěno
MER_INFO_KAL_1658_007 | 1658/gf/105:1658 | MER_INFO_KAL_1658_007 | 300 | 1658/gf/105:1658 | 64
MER_INFO_KAL_1658_004 | 1658/gf/112:1658 | MER_INFO_KAL_1658_004 | 600 | 1658/gf/112:1658 | 101
MER_INFO_KAL_1658_001 | 1658/gf/113:1658 | MER_INFO_KAL_1658_001 | 300 | 1658/gf/113:1658 | 106

# IfcLamp: ELSI_SZ_NO (3)
Classification: ELSI_SZ_NO Nouzové osvětlení (CS-BIM)
CSBIM_Pset - BatteryType: nezjištěno; CircuitNumber: neodpovídá typu; FamilyName: ONTEC; Floor: gf; InitialInspection: nezjištěno; LightingCircuit: nouzové osvětlení; Location: Strop / podhled – interiér; Manufacturer: TM Technologie; Switchboard: neodpovídá typu; TechnicalDocumentation: nezjištěno; Type1: Silnoproud; Type2: Světelné zdroje; Type3: Nouzové osvětlení; TypeDesignation: ONTEC C; TypeName: ELSI_SZ_NO
CSBIM_SourcePset - SourceTable: cobie_Component; GeometryMode: bounding_box; GeometrySourceTable: cobie_Component; GeometryRule: component_box; GeometryReason: CadType!=Object|missing_type_geometry
Name | In | Description = CSBIM_Pset, Description | Code = SourceKey = GeometrySourceKey | HeightAboveFloor | RoomNumber | SourceId
ELSI_SZ_NO_1658_001 | 1658/gf/101:1658 | Nouzové svítidlo | ELSI_SZ_NO_1658_001 | 2970 | 1658/gf/101:1658 | 6
ELSI_SZ_NO_1658_003 | 1658/gf/102:1658 | Nouzové svítidlo | ELSI_SZ_NO_1658_003 | 2670 | 1658/gf/102:1658 | 36
ELSI_SZ_NO_1658_004 | 1658/gf/102:1658 | Silnoproud · Světelné zdroje · Nouzové osvětlení | ELSI_SZ_NO_1658_004 | 2670 | 1658/gf/102:1658 | 35

# IfcLightFixture: ELSI_LOGO_IPP, ELSI_LOGO_IPP_1658_001
In: 1658/gf/102:1658
Description: Informační pylon volně stojící s podstavcem; Classification: ELSI_LOGO_IPP Informační pylon volně stojící s podstavcem (CS-BIM)
CSBIM_Pset - BatteryType: nezjištěno; CircuitNumber: nezjištěno; Code: ELSI_LOGO_IPP_1658_001; Description: Informační pylon volně stojící s podstavcem; FamilyName: nezjištěno; Floor: gf; HeightAboveFloor: 0; InitialInspection: nezjištěno; LightingCircuit: nezjištěno; Location: nezjištěno; Manufacturer: nezjištěno; RoomNumber: 1658/gf/102:1658; Switchboard: nezjištěno; TechnicalDocumentation: nezjištěno; Type1: Silnoproud; Type2: Světelné reklamy a loga; Type3: Informační pylon volně stojící s podstavcem; TypeDesignation: nezjištěno; TypeName: ELSI_LOGO_IPP
CSBIM_SourcePset - SourceTable: cobie_Component; SourceId: 29; SourceKey: ELSI_LOGO_IPP_1658_001; GeometryMode: bounding_box; GeometrySourceTable: cobie_Component; GeometrySourceKey: ELSI_LOGO_IPP_1658_001; GeometryRule: component_box; GeometryReason: CadType!=Object|missing_type_geometry

# IfcLightFixture: ELSI_LOGO_IPS, ELSI_LOGO_IPS_1658_001
In: 1658/gf/102:1658
Description: Informační pylon pro montáž na stěnu; Classification: ELSI_LOGO_IPS Informační pylon pro montáž na stěnu (CS-BIM)
CSBIM_Pset - BatteryType: nezjištěno; CircuitNumber: nezjištěno; Code: ELSI_LOGO_IPS_1658_001; Description: Informační pylon pro montáž na stěnu; FamilyName: nezjištěno; Floor: gf; HeightAboveFloor: 1130; InitialInspection: nezjištěno; LightingCircuit: nezjištěno; Location: nezjištěno; Manufacturer: nezjištěno; RoomNumber: 1658/gf/102:1658; Switchboard: nezjištěno; TechnicalDocumentation: nezjištěno; Type1: Silnoproud; Type2: Světelné reklamy a loga; Type3: Informační pylon pro montáž na stěnu; TypeDesignation: nezjištěno; TypeName: ELSI_LOGO_IPS
CSBIM_SourcePset - SourceTable: cobie_Component; SourceId: 24; SourceKey: ELSI_LOGO_IPS_1658_001; GeometryMode: bounding_box; GeometrySourceTable: cobie_Component; GeometrySourceKey: ELSI_LOGO_IPS_1658_001; GeometryRule: component_box; GeometryReason: CadType!=Object|missing_type_geometry

# IfcLightFixture: ELSI_LOGO_NNN, ELSI_LOGO_NNN_1658_001
In: 1658/gf/102:1658
Description: Nástěnný nápis - nový; Classification: ELSI_LOGO_NNN Nástěnný nápis - nový (CS-BIM)
CSBIM_Pset - BatteryType: nezjištěno; Code: ELSI_LOGO_NNN_1658_001; Description: Nástěnný nápis - nový; FamilyName: nezjištěno; Floor: gf; HeightAboveFloor: 0; InitialInspection: nezjištěno; LightingCircuit: nezjištěno; Location: interiér – na stěně; Manufacturer: nezjištěno; RoomNumber: 1658/gf/102:1658; Switchboard: nezjištěno; TechnicalDocumentation: nezjištěno; Type1: Silnoproud; Type2: Světelné reklamy a loga; Type3: Nástěnný nápis - nový; TypeDesignation: nezjištěno; TypeName: ELSI_LOGO_NNN
CSBIM_SourcePset - SourceTable: cobie_Component; SourceId: 20; SourceKey: ELSI_LOGO_NNN_1658_001; GeometryMode: bounding_box; GeometrySourceTable: cobie_Component; GeometrySourceKey: ELSI_LOGO_NNN_1658_001; GeometryRule: component_box; GeometryReason: CadType!=Object|missing_type_geometry

# IfcLightFixture: ELSI_LOGO_SPL, ELSI_LOGO_SPL_1658_001
In: 1658/gf/100:1658
Description: Světelný panel (logo); Classification: ELSI_LOGO_SPL Světelný panel (logo) (CS-BIM)
CSBIM_Pset - BatteryCount: 0; BatterySource: 0; BatteryType: Ne; CircuitNumber: nezjištěno; Code: ELSI_LOGO_SPL_1658_001; Description: Světelný panel (logo); FamilyName: nezjištěno; Floor: gf; HeightAboveFloor: 2650; InitialInspection: nezjištěno; LightingCircuit: nezjištěno; Location: exteriér – nad vstupem objektu (podhled); Manufacturer: nezjištěno; RoomNumber: 1658/gf/100:1658; Switchboard: nezjištěno; TechnicalDocumentation: nezjištěno; Type1: Silnoproud; Type2: Světelné reklamy a loga; Type3: Světelný panel (logo); TypeDesignation: nezjištěno; TypeName: ELSI_LOGO_SPL; Voltage: 220
CSBIM_SourcePset - SourceTable: cobie_Component; SourceId: 2; SourceKey: ELSI_LOGO_SPL_1658_001; GeometryMode: bounding_box; GeometrySourceTable: cobie_Component; GeometrySourceKey: ELSI_LOGO_SPL_1658_001; GeometryRule: component_box; GeometryReason: CadType!=Object|missing_type_geometry

# IfcLightFixture: ELSI_LOGO_VON, ELSI_LOGO_VON_1658_001
In: 1658/gf/100:1658
Description: Označení bankomatu výstrčka oboustranná - nováaaa; Classification: ELSI_LOGO_VON Označení bankomatu výstrčka oboustranná - nová (CS-BIM)
CSBIM_Pset - BatteryType: nezjištěno; CircuitNumber: nezjištěno; Code: ELSI_LOGO_VON_1658_001; Description: Označení bankomatu výstrčka oboustranná - nováaaa; FamilyName: nezjištěno; Floor: gf; HeightAboveFloor: 2480; InitialInspection: nezjištěno; LightingCircuit: nezjištěno; Location: Fasáda objektu – exteriér; konzolové uchycení na stěně.; Manufacturer: nezjištěno; RoomNumber: 1658/gf/100:1658; Switchboard: nezjištěno; TechnicalDocumentation: nezjištěno; Type1: Silnoproud; Type2: Světelné reklamy a loga; Type3: Označení bankomatu výstrčka oboustranná - nová; TypeDesignation: nezjištěno; TypeName: ELSI_LOGO_VON
CSBIM_SourcePset - SourceTable: cobie_Component; SourceId: 1; SourceKey: ELSI_LOGO_VON_1658_001; GeometryMode: bounding_box; GeometrySourceTable: cobie_Component; GeometrySourceKey: ELSI_LOGO_VON_1658_001; GeometryRule: component_box; GeometryReason: CadType!=Object|missing_type_geometry

# IfcLightFixture: ELSI_SZ_VEO (2)
In: 1658/gf/100:1658
Description: Silnoproud · Světelné zdroje · Venkovní osvětlení; Classification: ELSI_SZ_VEO Venkovní osvětlení (CS-BIM)
CSBIM_Pset - BatteryType: neodpovídá typu; CircuitNumber: neodpovídá typu; Description: Silnoproud · Světelné zdroje · Venkovní osvětlení; FamilyName: nezjištěno; Floor: gf; HeightAboveFloor: 2890; InitialInspection: nezjištěno; LightingCircuit: osvětlení; Location: Interiér – chodba / společné prostory; Manufacturer: nezjištěno; RoomNumber: 1658/gf/100:1658; Switchboard: neodpovídá typu; TechnicalDocumentation: nezjištěno; Type1: Silnoproud; Type2: Světelné zdroje; Type3: Venkovní osvětlení; TypeDesignation: nezjištěno; TypeName: ELSI_SZ_VEO
CSBIM_SourcePset - SourceTable: cobie_Component; GeometryMode: bounding_box; GeometrySourceTable: cobie_Component; GeometryRule: component_box; GeometryReason: CadType!=Object|missing_type_geometry
Name | Code = SourceKey = GeometrySourceKey | SourceId
ELSI_SZ_VEO_1658_001 | ELSI_SZ_VEO_1658_001 | 4
ELSI_SZ_VEO_1658_002 | ELSI_SZ_VEO_1658_002 | 3 | CSBIM_Pset - BatterySource: 0

# IfcLightFixture: ELSI_SZ_VNO (39)
Classification: ELSI_SZ_VNO Vnitřní osvětlení (CS-BIM)
CSBIM_Pset - BatteryType: neodpovídá typu; CircuitNumber: neodpovídá typu; Floor: gf; LightingCircuit: osvětlení; Switchboard: neodpovídá typu; Type1: Silnoproud; Type2: Světelné zdroje; Type3: Vnitřní osvětlení; TypeName: ELSI_SZ_VNO
CSBIM_SourcePset - SourceTable: cobie_Component; GeometryMode: bounding_box; GeometrySourceTable: cobie_Component; GeometryRule: component_box; GeometryReason: CadType!=Object|missing_type_geometry
Name | In | Description = CSBIM_Pset, Description | Code = SourceKey = GeometrySourceKey | FamilyName | HeightAboveFloor | InitialInspection | InputPower | Location | Manufacturer | RoomNumber | ServiceLife | TechnicalDocumentation | TypeDesignation | SourceId
ELSI_SZ_VNO_1658_001 | 1658/gf/101:1658 | Čtvercové svítidlo LED zapuštěné v podhledu | ELSI_SZ_VNO_1658_001 | světlo | 2670 | nezjištěno | 40 | Interiér – chodba / společné prostory | T-LED s.r.o. | 1658/gf/101:1658 | 50000 | 08.03 Dokladová část/0_TECHNICKÉ LISTY/světlo čtverec.pdf | UGRB6060 LED PANEL | 5 | CSBIM_Pset - WarrantyPeriod: 2
ELSI_SZ_VNO_1658_002 | 1658/gf/102:1658 | Čtvercové svítidlo LED zapuštěné v podhledu | ELSI_SZ_VNO_1658_002 | světlo | 2670 | nezjištěno | 40 | Interiér – chodba / společné prostory | T-LED s.r.o. | 1658/gf/102:1658 | 50000 | 08.03 Dokladová část/0_TECHNICKÉ LISTY/světlo čtverec.pdf | UGRB6060 LED PANEL | 13 | CSBIM_Pset - WarrantyPeriod: 2
ELSI_SZ_VNO_1658_003 | 1658/gf/102:1658 | Čtvercové svítidlo LED zapuštěné v podhledu | ELSI_SZ_VNO_1658_003 | světlo | 2670 | nezjištěno | 40 | Interiér – chodba / společné prostory | T-LED s.r.o. | 1658/gf/102:1658 | 50000 | 08.03 Dokladová část/0_TECHNICKÉ LISTY/světlo čtverec.pdf | UGRB6060 LED PANEL | 14 | CSBIM_Pset - WarrantyPeriod: 2
ELSI_SZ_VNO_1658_004 | 1658/gf/102:1658 | Čtvercové svítidlo LED zapuštěné v podhledu | ELSI_SZ_VNO_1658_004 | světlo | 2670 | nezjištěno | 40 | Interiér – chodba / společné prostory | T-LED s.r.o. | 1658/gf/102:1658 | 50000 | 08.03 Dokladová část/0_TECHNICKÉ LISTY/světlo čtverec.pdf | UGRB6060 LED PANEL | 15 | CSBIM_Pset - WarrantyPeriod: 2
ELSI_SZ_VNO_1658_005 | 1658/gf/102:1658 | Čtvercové svítidlo LED zapuštěné v podhledu | ELSI_SZ_VNO_1658_005 | světlo | 2670 | nezjištěno | 40 | Interiér – chodba / společné prostory | T-LED s.r.o. | 1658/gf/102:1658 | 50000 | 08.03 Dokladová část/0_TECHNICKÉ LISTY/světlo čtverec.pdf | UGRB6060 LED PANEL | 16 | CSBIM_Pset - WarrantyPeriod: 2
ELSI_SZ_VNO_1658_006 | 1658/gf/102:1658 | Čtvercové svítidlo LED zapuštěné v podhledu | ELSI_SZ_VNO_1658_006 | světlo | 2670 | nezjištěno | 40 | Interiér – chodba / společné prostory | T-LED s.r.o. | 1658/gf/102:1658 | 50000 | 08.03 Dokladová část/0_TECHNICKÉ LISTY/světlo čtverec.pdf | UGRB6060 LED PANEL | 17 | CSBIM_Pset - WarrantyPeriod: 2
ELSI_SZ_VNO_1658_007 | 1658/gf/102:1658 | Čtvercové svítidlo LED zapuštěné v podhledu | ELSI_SZ_VNO_1658_007 | světlo | 2670 | nezjištěno | 40 | Interiér – chodba / společné prostory | T-LED s.r.o. | 1658/gf/102:1658 | 50000 | 08.03 Dokladová část/0_TECHNICKÉ LISTY/světlo čtverec.pdf | UGRB6060 LED PANEL | 18 | CSBIM_Pset - WarrantyPeriod: 2
ELSI_SZ_VNO_1658_008 | 1658/gf/102:1658 | Čtvercové svítidlo LED zapuštěné v podhledu | ELSI_SZ_VNO_1658_008 | světlo | 2670 | nezjištěno | 40 | Interiér – chodba / společné prostory | T-LED s.r.o. | 1658/gf/102:1658 | 50000 | 08.03 Dokladová část/0_TECHNICKÉ LISTY/světlo čtverec.pdf | UGRB6060 LED PANEL | 19 | CSBIM_Pset - WarrantyPeriod: 2
ELSI_SZ_VNO_1658_009 | 1658/gf/102:1658 | Čtvercové svítidlo LED zapuštěné v podhledu | ELSI_SZ_VNO_1658_009 | světlo | 2670 | nezjištěno | 40 | Interiér – chodba / společné prostory | T-LED s.r.o. | 1658/gf/102:1658 | 50000 | 08.03 Dokladová část/0_TECHNICKÉ LISTY/světlo čtverec.pdf | UGRB6060 LED PANEL | 12 | CSBIM_Pset - WarrantyPeriod: 2
ELSI_SZ_VNO_1658_010 | 1658/gf/102:1658 | Čtvercové svítidlo LED zapuštěné v podhledu | ELSI_SZ_VNO_1658_010 | světlo | 2670 | nezjištěno | 40 | Interiér – chodba / společné prostory | T-LED s.r.o. | 1658/gf/102:1658 | 50000 | 08.03 Dokladová část/0_TECHNICKÉ LISTY/světlo čtverec.pdf | UGRB6060 LED PANEL | 11 | CSBIM_Pset - WarrantyPeriod: 2
ELSI_SZ_VNO_1658_011 | 1658/gf/102:1658 | Čtvercové svítidlo LED zapuštěné v podhledu | ELSI_SZ_VNO_1658_011 | světlo | 2670 | nezjištěno | 40 | Interiér – chodba / společné prostory | T-LED s.r.o. | 1658/gf/102:1658 | 50000 | 08.03 Dokladová část/0_TECHNICKÉ LISTY/světlo čtverec.pdf | UGRB6060 LED PANEL | 10 | CSBIM_Pset - WarrantyPeriod: 2
ELSI_SZ_VNO_1658_026 | 1658/gf/102:1658 | Čtvercové svítidlo LED zapuštěné v podhledu | ELSI_SZ_VNO_1658_026 | nezjištěno | 2670 | nezjištěno |  | Interiér – chodba / společné prostory | nezjištěno | 1658/gf/102:1658 |  | nezjištěno | nezjištěno | 37
ELSI_SZ_VNO_1658_037 | 1658/gf/102:1658 | Silnoproud · Světelné zdroje · Vnitřní osvětlení | ELSI_SZ_VNO_1658_037 | Osvětlení | 2300 | viz revizní zpráva elektro |  | Interiér – strop (závěsné) | Intralighting | 1658/gf/102:1658 |  | Protokol o kontrolním měření EO + technický list Wave | Lona SDI 600 h100 DPR 4000+990 lm 52W 830 DALI IP20 | 21
ELSI_SZ_VNO_1658_013 | 1658/gf/103:1658 | Downlight zapuštěný v podhledu (větší) | ELSI_SZ_VNO_1658_013 | světlo | 2500 | nezjištěno | 22 | Interiér – strop (podhled) | nezjištěno | 1658/gf/103:1658 | 50000 | 08.03 Dokladová část/0_TECHNICKÉ LISTY/svetlo bodove velke.pdf | Office RDS ELSDSCL22W-R12 | 47
ELSI_SZ_VNO_1658_014 | 1658/gf/103:1658 | Downlight zapuštěný v podhledu (větší) | ELSI_SZ_VNO_1658_014 | světlo | 2500 | nezjištěno | 22 | Interiér – strop (podhled) | nezjištěno | 1658/gf/103:1658 | 50000 | 08.03 Dokladová část/0_TECHNICKÉ LISTY/svetlo bodove velke.pdf | Office RDS ELSDSCL22W-R12 | 48
ELSI_SZ_VNO_1658_027 | 1658/gf/104:1658 | Downlight kruhový zavěšený | ELSI_SZ_VNO_1658_027 | Lona | 2000 | nezjištěno | 0.05162 | Interiér – strop (závěs) | Intralighting | 1658/gf/104:1658 |  | Uhříněves - výpočet pdf.pdf (Relux výpočet osvětlení) | Lona SDI 600 h100 DPR 4000+990 lm 52 W 830 DALI IP20 black | 61 | CSBIM_Pset - Power: 0.05162
ELSI_SZ_VNO_1658_029 | 1658/gf/104:1658 | Downlight zapuštěný v podhledu (menší) | ELSI_SZ_VNO_1658_029 | světlo | 2670 | nezjištěno |  | Interiér – strop (zapuštěné v podhledu) | Intra lighting | 1658/gf/104:1658 | 50000 | 08.03 Dokladová část/0_TECHNICKÉ LISTY/svetlo bodove male.pdf | Pipes RVS | 60
ELSI_SZ_VNO_1658_030 | 1658/gf/104:1658 | Downlight zapuštěný v podhledu (menší) | ELSI_SZ_VNO_1658_030 | světlo | 2670 | nezjištěno |  | Interiér – strop (zapuštěné v podhledu) | Intra lighting | 1658/gf/104:1658 | 50000 | 08.03 Dokladová část/0_TECHNICKÉ LISTY/svetlo bodove male.pdf | Pipes RVS | 56
ELSI_SZ_VNO_1658_031 | 1658/gf/104:1658 | Downlight zapuštěný v podhledu (menší) | ELSI_SZ_VNO_1658_031 | světlo | 2670 | nezjištěno |  | Interiér – strop (zapuštěné v podhledu) | Intra lighting | 1658/gf/104:1658 | 50000 | 08.03 Dokladová část/0_TECHNICKÉ LISTY/svetlo bodove male.pdf | Pipes RVS | 57
ELSI_SZ_VNO_1658_032 | 1658/gf/104:1658 | Downlight zapuštěný v podhledu (menší) | ELSI_SZ_VNO_1658_032 | světlo | 2670 | nezjištěno |  | Interiér – strop (zapuštěné v podhledu) | Intra lighting | 1658/gf/104:1658 | 50000 | 08.03 Dokladová část/0_TECHNICKÉ LISTY/svetlo bodove male.pdf | Pipes RVS | 55
ELSI_SZ_VNO_1658_015 | 1658/gf/105:1658 | Downlight zapuštěný v podhledu (větší) | ELSI_SZ_VNO_1658_015 | světlo | 2200 | nezjištěno | 22 | Interiér – strop (podhled) | nezjištěno | 1658/gf/105:1658 | 50000 | 08.03 Dokladová část/0_TECHNICKÉ LISTY/svetlo bodove velke.pdf | Office RDS ELSDSCL22W-R12 | 63
ELSI_SZ_VNO_1658_016 | 1658/gf/105:1658 | Downlight zapuštěný v podhledu (větší) | ELSI_SZ_VNO_1658_016 | světlo | 2200 | nezjištěno | 22 | Interiér – strop (podhled) | nezjištěno | 1658/gf/105:1658 | 50000 | 08.03 Dokladová část/0_TECHNICKÉ LISTY/svetlo bodove velke.pdf | Office RDS ELSDSCL22W-R12 | 75
ELSI_SZ_VNO_1658_017 | 1658/gf/105:1658 | Downlight zapuštěný v podhledu (větší) | ELSI_SZ_VNO_1658_017 | světlo | 2200 | nezjištěno | 22 | Interiér – strop (podhled) | nezjištěno | 1658/gf/105:1658 | 50000 | 08.03 Dokladová část/0_TECHNICKÉ LISTY/svetlo bodove velke.pdf | Office RDS ELSDSCL22W-R12 | 76
ELSI_SZ_VNO_1658_018 | 1658/gf/105:1658 | Downlight zapuštěný v podhledu (větší) | ELSI_SZ_VNO_1658_018 | světlo | 2200 | nezjištěno | 22 | Interiér – strop (podhled) | nezjištěno | 1658/gf/105:1658 | 50000 | 08.03 Dokladová část/0_TECHNICKÉ LISTY/svetlo bodove velke.pdf | Office RDS ELSDSCL22W-R12 | 77
ELSI_SZ_VNO_1658_019 | 1658/gf/105:1658 | Downlight zapuštěný v podhledu (větší) | ELSI_SZ_VNO_1658_019 | světlo | 2200 | nezjištěno | 22 | Interiér – strop (podhled) | nezjištěno | 1658/gf/105:1658 | 50000 | 08.03 Dokladová část/0_TECHNICKÉ LISTY/svetlo bodove velke.pdf | Office RDS ELSDSCL22W-R12 | 78
ELSI_SZ_VNO_1658_021 | 1658/gf/106:1658 | Downlight zapuštěný v podhledu (větší) | ELSI_SZ_VNO_1658_021 | světlo | 2420 | nezjištěno | 22 | Interiér – strop (podhled) | nezjištěno | 1658/gf/106:1658 | 50000 | 08.03 Dokladová část/0_TECHNICKÉ LISTY/svetlo bodove velke.pdf | Office RDS ELSDSCL22W-R12 | 85
ELSI_SZ_VNO_1658_025 | 1658/gf/106:1658 | Čtvercové svítidlo LED zapuštěné v podhledu | ELSI_SZ_VNO_1658_025 | Office Back | 2420 | ne |  | Interiér – chodba / společné prostory | Ecoled | 1658/gf/106:1658 |  | RELUX světelný výpočet 08.10.2025 | Office Back 6060 UGR 40W | 86
ELSI_SZ_VNO_1658_022 | 1658/gf/108:1658 | Downlight zapuštěný v podhledu (větší) | ELSI_SZ_VNO_1658_022 | světlo | 2200 | nezjištěno | 22 | Interiér – strop (podhled) | nezjištěno | 1658/gf/108:1658 | 50000 | 08.03 Dokladová část/0_TECHNICKÉ LISTY/svetlo bodove velke.pdf | Office RDS ELSDSCL22W-R12 | 90
ELSI_SZ_VNO_1658_023 | 1658/gf/109:1658 | Downlight zapuštěný v podhledu (větší) | ELSI_SZ_VNO_1658_023 | světlo | 2200 | nezjištěno | 22 | Interiér – strop (podhled) | nezjištěno | 1658/gf/109:1658 | 50000 | 08.03 Dokladová část/0_TECHNICKÉ LISTY/svetlo bodove velke.pdf | Office RDS ELSDSCL22W-R12 | 94
ELSI_SZ_VNO_1658_024 | 1658/gf/110:1658 | Downlight zapuštěný v podhledu (větší) | ELSI_SZ_VNO_1658_024 | světlo | 2200 | nezjištěno | 22 | Interiér – strop (podhled) | nezjištěno | 1658/gf/110:1658 | 50000 | 08.03 Dokladová část/0_TECHNICKÉ LISTY/svetlo bodove velke.pdf | Office RDS ELSDSCL22W-R12 | 98
ELSI_SZ_VNO_1658_012 | 1658/gf/111:1658 | Čtvercové svítidlo LED zapuštěné v podhledu | ELSI_SZ_VNO_1658_012 | světlo | 2670 | nezjištěno | 40 | Interiér – chodba / společné prostory | T-LED s.r.o. | 1658/gf/111:1658 | 50000 | 08.03 Dokladová část/0_TECHNICKÉ LISTY/světlo čtverec.pdf | UGRB6060 LED PANEL | 100 | CSBIM_Pset - WarrantyPeriod: 2
ELSI_SZ_VNO_1658_038 | 1658/gf/112:1658 | Silnoproud · Světelné zdroje · Vnitřní osvětlení | ELSI_SZ_VNO_1658_038 | světlo | 2790 | nezjištěno | 40 | Interiér – strop (přisazené) | T-LED s.r.o. | 1658/gf/112:1658 | 50000 | 08.03 Dokladová část/0_TECHNICKÉ LISTY/světlo čtverec.pdf | UGRB30120 LED PANEL | 103 | CSBIM_Pset - WarrantyPeriod: 2
ELSI_SZ_VNO_1658_039 | 1658/gf/112:1658 | Silnoproud · Světelné zdroje · Vnitřní osvětlení | ELSI_SZ_VNO_1658_039 | světlo | 2790 | nezjištěno | 40 | Interiér – strop (přisazené) | T-LED s.r.o. | 1658/gf/112:1658 | 50000 | 08.03 Dokladová část/0_TECHNICKÉ LISTY/světlo čtverec.pdf | UGRB30120 LED PANEL | 104 | CSBIM_Pset - WarrantyPeriod: 2
ELSI_SZ_VNO_1658_028 | 1658/gf/113:1658 | Downlight kruhový zavěšený | ELSI_SZ_VNO_1658_028 | Lona | 1850 | nezjištěno | 0.05162 | Interiér – strop (závěs) | Intralighting | 1658/gf/113:1658 |  | Uhříněves - výpočet pdf.pdf (Relux výpočet osvětlení) | Lona SDI 600 h100 DPR 4000+990 lm 52 W 830 DALI IP20 black | 105 | CSBIM_Pset - Power: 0.05162
ELSI_SZ_VNO_1658_033 | 1658/gf/113:1658 | Downlight zapuštěný v podhledu (menší) | ELSI_SZ_VNO_1658_033 | světlo | 2670 | nezjištěno |  | Interiér – strop (zapuštěné v podhledu) | Intra lighting | 1658/gf/113:1658 | 50000 | 08.03 Dokladová část/0_TECHNICKÉ LISTY/svetlo bodove male.pdf | Pipes RVS | 112
ELSI_SZ_VNO_1658_034 | 1658/gf/113:1658 | Downlight zapuštěný v podhledu (menší) | ELSI_SZ_VNO_1658_034 | světlo | 2670 | nezjištěno |  | Interiér – strop (zapuštěné v podhledu) | Intra lighting | 1658/gf/113:1658 | 50000 | 08.03 Dokladová část/0_TECHNICKÉ LISTY/svetlo bodove male.pdf | Pipes RVS | 111
ELSI_SZ_VNO_1658_035 | 1658/gf/113:1658 | Downlight zapuštěný v podhledu (menší) | ELSI_SZ_VNO_1658_035 | světlo | 2670 | nezjištěno |  | Interiér – strop (zapuštěné v podhledu) | Intra lighting | 1658/gf/113:1658 | 50000 | 08.03 Dokladová část/0_TECHNICKÉ LISTY/svetlo bodove male.pdf | Pipes RVS | 110
ELSI_SZ_VNO_1658_036 | 1658/gf/113:1658 | Downlight zapuštěný v podhledu (menší) | ELSI_SZ_VNO_1658_036 | světlo | 2670 | nezjištěno |  | Interiér – strop (zapuštěné v podhledu) | Intra lighting | 1658/gf/113:1658 | 50000 | 08.03 Dokladová část/0_TECHNICKÉ LISTY/svetlo bodove male.pdf | Pipes RVS | 109
ELSI_SZ_VNO_1658_020 | 1658/gf/114:1658 | Downlight zapuštěný v podhledu (větší) | ELSI_SZ_VNO_1658_020 | světlo | 2200 | nezjištěno | 22 | Interiér – strop (podhled) | nezjištěno | 1658/gf/114:1658 | 50000 | 08.03 Dokladová část/0_TECHNICKÉ LISTY/svetlo bodove velke.pdf | Office RDS ELSDSCL22W-R12 | 119

# IfcSanitaryTerminal: PBZ_SAPO_HVNI, PBZ_SAPO_HVNI_1658_001
In: 1658/gf/102:1658
Description: PBZ · Systém aktivní požární ochrany · Hydranty vnitřní; Classification: PBZ_SAPO_HVNI Hydranty vnitřní (CS-BIM)
CSBIM_Pset - Code: PBZ_SAPO_HVNI_1658_001; Description: PBZ · Systém aktivní požární ochrany · Hydranty vnitřní; Diameter: 25; FamilyName: Požární zařízení; Floor: gf; Height: nezjištěno; HeightAboveFloor: 940; InitialInspection: ano; InnerDiameter: neodpovídá typu; Location: interiér; Manufacturer: nezjištěno; Material: ocel; NominalDiameter: DN 25; OuterDiameter: neodpovídá typu; RoomNumber: 1658/gf/102:1658; Size: 30 m hadice; SystemClassification: Požární ochrana; SystemType: Požární vodovod; Type1: PBZ; Type2: Systém aktivní požární ochrany; Type3: Hydranty vnitřní; TypeDesignation: D25 130m; TypeName: PBZ_SAPO_HVNI; Width: nezjištěno
CSBIM_SourcePset - SourceTable: cobie_Component; SourceId: 25; SourceKey: PBZ_SAPO_HVNI_1658_001; GeometryMode: bounding_box; GeometrySourceTable: cobie_Component; GeometrySourceKey: PBZ_SAPO_HVNI_1658_001; GeometryRule: component_box; GeometryReason: CadType!=Object|missing_type_geometry

# IfcSanitaryTerminal: ZTI_ZP_K, ZTI_ZP_K_1658_001
In: 1658/gf/105:1658
Description: ZTI · Zařizovací předměty · Kuchyňka (dřezy); Classification: ZTI_ZP_K Kuchyňka (dřezy) (CS-BIM)
CSBIM_Pset - Code: ZTI_ZP_K_1658_001; Description: ZTI · Zařizovací předměty · Kuchyňka (dřezy); FamilyName: nezjištěno; Floor: gf; HeightAboveFloor: 520; InitialInspection: neodpovídá typu; Location: Interiér – kuchyňka / zázemí; Manufacturer: nezjištěno; Material: nerez; RoomNumber: 1658/gf/105:1658; SystemClassification: sanitární zařízení; SystemType: mytí / hygienické zázemí; Type1: ZTI; Type2: Zařizovací předměty; Type3: Kuchyňka (dřezy); TypeDesignation: nezjištěno; TypeName: ZTI_ZP_K
CSBIM_SourcePset - SourceTable: cobie_Component; SourceId: 72; SourceKey: ZTI_ZP_K_1658_001; GeometryMode: bounding_box; GeometrySourceTable: cobie_Component; GeometrySourceKey: ZTI_ZP_K_1658_001; GeometryRule: component_box; GeometryReason: CadType!=Object|missing_type_geometry

# IfcSanitaryTerminal: ZTI_ZP_U, ZTI_ZP_U_1658_001
In: 1658/gf/109:1658
Description: ZTI · Zařizovací předměty · Umyvadla; Classification: ZTI_ZP_U Umyvadla (CS-BIM)
CSBIM_Pset - Code: ZTI_ZP_U_1658_001; Description: ZTI · Zařizovací předměty · Umyvadla; FamilyName: nezjištěno; Floor: gf; HeightAboveFloor: 450; InitialInspection: neodpovídá typu; Location: Interiér – WC / umývárna; Manufacturer: nezjištěno; Material: keramika; RoomNumber: 1658/gf/109:1658; SystemClassification: sanitární zařízení; SystemType: osobní hygiena; Type1: ZTI; Type2: Zařizovací předměty; Type3: Umyvadla; TypeDesignation: nezjištěno; TypeName: ZTI_ZP_U
CSBIM_SourcePset - SourceTable: cobie_Component; SourceId: 92; SourceKey: ZTI_ZP_U_1658_001; GeometryMode: bounding_box; GeometrySourceTable: cobie_Component; GeometrySourceKey: ZTI_ZP_U_1658_001; GeometryRule: component_box; GeometryReason: CadType!=Object|missing_type_geometry

# IfcSanitaryTerminal: ZTI_ZP_VL, ZTI_ZP_VL_1658_001
In: 1658/gf/114:1658
Description: Výlevka; Classification: ZTI_ZP_VL Výlevka (CS-BIM)
CSBIM_Pset - Code: ZTI_ZP_VL_1658_001; Description: Výlevka; FamilyName: nezjištěno; Floor: gf; HeightAboveFloor: 0; InitialInspection: neodpovídá typu; Location: úklidová místnost / sklad úklidu; Manufacturer: nezjištěno; Material: keramika; RoomNumber: 1658/gf/114:1658; SystemClassification: neodpovídá typu; SystemType: neodpovídá typu; Type1: ZTI; Type2: Zařizovací předměty; Type3: Výlevka; TypeDesignation: nezjištěno; TypeName: ZTI_ZP_VL
CSBIM_SourcePset - SourceTable: cobie_Component; SourceId: 117; SourceKey: ZTI_ZP_VL_1658_001; GeometryMode: bounding_box; GeometrySourceTable: cobie_Component; GeometrySourceKey: ZTI_ZP_VL_1658_001; GeometryRule: component_box; GeometryReason: CadType!=Object|missing_type_geometry

# IfcSanitaryTerminal: ZTI_ZP_WC (2)
Description: ZTI · Zařizovací předměty · WC; Classification: ZTI_ZP_WC WC (CS-BIM)
CSBIM_Pset - Description: ZTI · Zařizovací předměty · WC; FamilyName: nezjištěno; Floor: gf; InitialInspection: neodpovídá typu; Location: WC / toaleta; Manufacturer: nezjištěno; Material: keramika; SystemClassification: neodpovídá typu; SystemType: neodpovídá typu; Type1: ZTI; Type2: Zařizovací předměty; Type3: WC; TypeDesignation: nezjištěno
CSBIM_SourcePset - SourceTable: cobie_Component; GeometryMode: bounding_box; GeometrySourceTable: cobie_Component; GeometryRule: component_box; GeometryReason: CadType!=Object|missing_type_geometry
Name | In | Code = SourceKey = GeometrySourceKey | HeightAboveFloor | RoomNumber | TypeName | SourceId
ZTI_ZP_WC_1658_001 | 1658/gf/108:1658 | ZTI_ZP_WC_1658_001 | 0 | 1658/gf/108:1658 | ZTI_ZP_WC | 88
ZTI_ZP_WC_1658_002 | 1658/gf/110:1658 | ZTI_ZP_WC_1658_002 | neodpovídá typu | 1658/gf/110 | nezjištěno | 96 | CSBIM_Pset - ActivationDate: nezjištěno; Diameter: neodpovídá typu; Height: nezjištěno; InnerDiameter: neodpovídá typu; NominalDiameter: neodpovídá typu; OuterDiameter: neodpovídá typu; RequiresCheck: ne; RequiresInspection: ne; ServiceLife: nezjištěno; Size: nezjištěno; WarrantyPeriod: nezjištěno; Width: nezjištěno; YearOfManufacture: nezjištěno

# IfcUnitaryEquipment: CHL_VEN_SPLIT (2)
In: 1658/gf/104:1658
Description: Chlad · Venkovní jednotky · Split; Classification: CHL_VEN_SPLIT Split (CS-BIM)
CSBIM_Pset - BatteryType: neodpovídá typu; CircuitNumber: nezjištěno; Description: Chlad · Venkovní jednotky · Split; Floor: gf; HeightAboveFloor: 3500; InitialInspection: ne; Manufacturer: Toshiba; RoomNumber: 1658/gf/104:1658; Switchboard: nezjištěno; SystemClassification: klimatizační zařízení; SystemType: split; Type1: Chlad; Type2: Venkovní jednotky; Type3: Split; TypeName: CHL_VEN_SPLIT
CSBIM_SourcePset - SourceTable: cobie_Component; GeometryMode: bounding_box; GeometrySourceTable: cobie_Component; GeometryRule: component_box; GeometryReason: CadType!=Object|missing_type_geometry
Name | Code = SourceKey = GeometrySourceKey | FamilyName | FilterType | Location | Refrigerant | TechnicalDocumentation | TypeDesignation | Voltage | Weight | SourceId
CHL_VEN_SPLIT_1658_001 | CHL_VEN_SPLIT_1658_001 | Digital Inverter | neodpovídá typu | exteriér – fasáda objektu | R32 | Výrobní štítek Toshiba RAV-GM301ATP-E, rok 2022 | RAV-GM301ATP-E | 230 | 29 | 54
CHL_VEN_SPLIT_1658_002 | CHL_VEN_SPLIT_1658_002 | nezjištěno | nezjištěno | interiér – technická místnost / VZT prostor | R410A | Výrobní štítek Toshiba MCY-MHP0504HSB-E, rok 2025 | MCY-MHP0504HSB-E | 400 | 125 | 53

# IfcUnitaryEquipment: CHL_VNI_KAZ (4)
Description: Kazetová klimatizační jednotka; Classification: CHL_VNI_KAZ Kazetová (CS-BIM)
CSBIM_Pset - BatteryType: neodpovídá typu; CircuitNumber: nezjištěno; Description: Kazetová klimatizační jednotka; FamilyName: nezjištěno; FilterType: nezjištěno; Floor: gf; HeightAboveFloor: 2670; InitialInspection: neodpovídá typu; Location: strop – podhled; Manufacturer: Toshiba; Refrigerant: nezjištěno; Switchboard: nezjištěno; SystemClassification: klimatizační zařízení; SystemType: nezjištěno; TechnicalDocumentation: nezjištěno; Type1: Chlad; Type2: Vnitřní jednotky; Type3: Kazetová; TypeDesignation: nezjištěno; TypeName: CHL_VNI_KAZ
CSBIM_SourcePset - SourceTable: cobie_Component; GeometryMode: bounding_box; GeometrySourceTable: cobie_Component; GeometryRule: component_box; GeometryReason: CadType!=Object|missing_type_geometry
Name | In | Code = SourceKey = GeometrySourceKey | RoomNumber | SourceId
CHL_VNI_KAZ_1658_002 | 1658/gf/102:1658 | CHL_VNI_KAZ_1658_002 | 1658/gf/102:1658 | 41
CHL_VNI_KAZ_1658_003 | 1658/gf/102:1658 | CHL_VNI_KAZ_1658_003 | 1658/gf/102:1658 | 42
CHL_VNI_KAZ_1658_004 | 1658/gf/104:1658 | CHL_VNI_KAZ_1658_004 | 1658/gf/104:1658 | 62
CHL_VNI_KAZ_1658_001 | 1658/gf/113:1658 | CHL_VNI_KAZ_1658_001 | 1658/gf/113:1658 | 113

# IfcUnitaryEquipment: CHL_VNI_NAS, CHL_VNI_NAS_1658_001
In: 1658/gf/106:1658
Description: Chlad · Vnitřní jednotky · Nástěnná; Classification: CHL_VNI_NAS Nástěnná (CS-BIM)
CSBIM_Pset - BatteryType: neodpovídá typu; CircuitNumber: nezjištěno; Code: CHL_VNI_NAS_1658_001; Depth: 230; Description: Chlad · Vnitřní jednotky · Nástěnná; FamilyName: nezjištěno; FilterType: nezjištěno; Floor: gf; Height: 293; HeightAboveFloor: 2130; InitialInspection: nezjištěno; InputPower: 0.04; Location: nezjištěno; Manufacturer: TOSHIBA (Toshiba Carrier (Thailand) Co., Ltd.); Power: 2.5; Refrigerant: R32; RoomNumber: 1658/gf/106:1658; Switchboard: nezjištěno; SystemClassification: nezjištěno; SystemType: nezjištěno; TechnicalDocumentation: nezjištěno; Type1: Chlad; Type2: Vnitřní jednotky; Type3: Nástěnná; TypeDesignation: RAV-HM301KRTP-E; TypeName: CHL_VNI_NAS; Weight: 10; Width: 798
CSBIM_SourcePset - SourceTable: cobie_Component; SourceId: 80; SourceKey: CHL_VNI_NAS_1658_001; GeometryMode: bounding_box; GeometrySourceTable: cobie_Component; GeometrySourceKey: CHL_VNI_NAS_1658_001; GeometryRule: component_box; GeometryReason: CadType!=Object|missing_type_geometry

# IfcUnitaryEquipment: TEP_ROZ_KZ (5)
Classification: TEP_ROZ_KZ Koncové zařízení, rozvody (otopná tělesa) (CS-BIM)
CSBIM_Pset - BatteryType: neodpovídá typu; CircuitNumber: neodpovídá typu; FilterType: neodpovídá typu; Floor: gf; Refrigerant: neodpovídá typu; Switchboard: neodpovídá typu; TechnicalDocumentation: nezjištěno; Type1: Teplo; Type2: Rozvody - ÚT, TUV a koncové zařízení; Type3: Koncové zařízení, rozvody (otopná tělesa); TypeDesignation: nezjištěno; TypeName: TEP_ROZ_KZ
CSBIM_SourcePset - SourceTable: cobie_Component; GeometryMode: bounding_box; GeometrySourceTable: cobie_Component; GeometryRule: component_box; GeometryReason: CadType!=Object|missing_type_geometry
Name | In | Description = CSBIM_Pset, Description | Code = SourceKey = GeometrySourceKey | FamilyName | HeightAboveFloor | InitialInspection | Location | Manufacturer | RoomNumber | SystemClassification | SystemType | SourceId
TEP_ROZ_KZ_1658_009 | 1658/gf/102:1658 | Panel UT deskový svislý | TEP_ROZ_KZ_1658_009 | Vertex Plan | 170 | neodpovídá typu | interiér – na stěně | Stelrad | 1658/gf/102:1658 | otopné těleso | teplovodní otopná soustava | 23 | CSBIM_Pset - Depth: 200; Height: 2000; Width: 600
TEP_ROZ_KZ_1658_003 | 1658/gf/104:1658 | Teplo · Rozvody - ÚT, TUV a koncové zařízení, rozvody (otopná tělesa) | TEP_ROZ_KZ_1658_003 | Otopná tělesa | 200 | neodpovídá typu | interiér – u stěny | nezjištěno | 1658/gf/104:1658 | Technické zařízení budovy | Vytápění | 50
TEP_ROZ_KZ_1658_011 | 1658/gf/105:1658 | Teplo · Rozvody - ÚT, TUV a koncové zařízení · Koncové zařízení, rozvody (otopná tělesa) | TEP_ROZ_KZ_1658_011 | nezjištěno | 200 | neodpovídá typu | interiér | nezjištěno | 1658/gf/105:1658 | nezjištěno | nezjištěno | 66
TEP_ROZ_KZ_1658_010 | 1658/gf/112:1658 | Teplo · Rozvody - ÚT, TUV a koncové zařízení · Koncové zařízení, rozvody (otopná tělesa) | TEP_ROZ_KZ_1658_010 | nezjištěno | 200 | neodpovídá typu | interiér | nezjištěno | 1658/gf/112:1658 | nezjištěno | nezjištěno | 102
TEP_ROZ_KZ_1658_001 | 1658/gf/113:1658 | Teplo · Rozvody - ÚT, TUV a koncové zařízení · Koncové zařízení, rozvody (otopná tělesa) | TEP_ROZ_KZ_1658_001 | Otopná tělesa | 100 | ne | interiér – u fasádního okna | MINIBO | 1658/gf/113:1658 | Technické zařízení budovy | Vytápění | 107

# IfcUnitaryEquipment: VZT_JEDN_REKOHR, VZT_JEDN_REKOHR_1658_001
In: 1658/gf/105:1658
Description: VZT · VZT jednotky kombinované · VZT s rekuperací a ohřevem; Classification: VZT_JEDN_REKOHR VZT s rekuperací a ohřevem (CS-BIM)
CSBIM_Pset - BatteryType: neodpovídá typu; CircuitNumber: neodpovídá typu; Code: VZT_JEDN_REKOHR_1658_001; Description: VZT · VZT jednotky kombinované · VZT s rekuperací a ohřevem; FamilyName: nezjištěno; FilterType: G4 (alternativně M5 nebo F7); Floor: gf; Height: 1100; HeightAboveFloor: 2200; InitialInspection: neodpovídá typu; Length: 1920; Location: nezjištěno; Manufacturer: ATREA s.r.o.; Refrigerant: neodpovídá typu; RoomNumber: 1658/gf/105:1658; Switchboard: nezjištěno; SystemClassification: neodpovídá typu; SystemType: neodpovídá typu; TechnicalDocumentation: Technický list ATREA – DUPLEX 500 až 9000 MultiEco (vydání 11/2020).; Type1: VZT; Type2: VZT jednotky kombinované; Type3: VZT s rekuperací a ohřevem; TypeDesignation: DUPLEX 1100 MultiEco; TypeName: VZT_JEDN_REKOHR; Voltage: 230; Width: 384
CSBIM_SourcePset - SourceTable: cobie_Component; SourceId: 69; SourceKey: VZT_JEDN_REKOHR_1658_001; GeometryMode: bounding_box; GeometrySourceTable: cobie_Component; GeometrySourceKey: VZT_JEDN_REKOHR_1658_001; GeometryRule: component_box; GeometryReason: CadType!=Object|missing_type_geometry

# IfcWindow: OB_INT_OK (3)
Description: Objekt · Interiéry · Okna; Classification: OB_INT_OK Okna (CS-BIM)
CSBIM_Pset - Color: bílá; Description: Objekt · Interiéry · Okna; Designation: nezjištěno; FillMaterial: sklo; FireResistance: nezjištěno; Floor: gf; HeightAboveFloor: 1900; InitialInspection: neodpovídá typu; Manufacturer: nezjištěno; Type1: Objekt; Type2: Interiéry; Type3: Okna; TypeDesignation: nezjištěno; TypeName: OB_INT_OK
CSBIM_SourcePset - SourceTable: cobie_Component; GeometryMode: bounding_box; GeometrySourceTable: cobie_Component; GeometryRule: component_box; GeometryReason: CadType!=Object|missing_type_geometry
Name | In | Code = SourceKey = GeometrySourceKey | FamilyName | HardwareType | LeafType | Location | OpeningType | RoomNumber | SourceId
OB_INT_OK_1658_004 | 1658/gf/103:1658 | OB_INT_OK_1658_004 | Okna | standardní okenní kování | prosklené | obvodová stěna budovy | výklopné / sklopné | 1658/gf/103:1658 | 45
OB_INT_OK_1658_003 | 1658/gf/104:1658 | OB_INT_OK_1658_003 | Okna | standardní okenní kování | prosklené | obvodová stěna budovy | otevíravé / sklopné | 1658/gf/104:1658 | 51
OB_INT_OK_1658_005 | 1658/gf/105:1658 | OB_INT_OK_1658_005 | nezjištěno | nezjištěno | nezjištěno | interiér – obvodová stěna | nezjištěno | 1658/gf/105:1658 | 67 | CSBIM_Pset - FrameMaterial: plast; Material: nezjištěno
